; ************************************************************************************************
; ************************************************************************************************
;
;		Name:		pokedoke.asm
;		Purpose:	Poke and Doke
;		Created:	7th December 2003
;		Reviewed: 	No
;		Author:		Paul Robson (paul@robsons.org.uk)
;
; ************************************************************************************************
; ************************************************************************************************

		.section code

; ************************************************************************************************
;
; 											Entry points
;
; ************************************************************************************************

PokeCommand: ;; [poke]
		sec
		bra 	PokeDokeCommon
DokeCommand: ;; [doke]
		clc

PokeDokeCommon:
		php
		ldx 	#0
		jsr 	EXPEvalInteger16			; address
		jsr 	ERRCheckComma
		inx
		jsr 	EXPEvalInteger16			; data
		dex

		lda 	XSNumber0,x
		sta 	zTemp0
		lda 	XSNumber1,x
		sta 	zTemp0+1
		;
		lda 	XSNumber0+1,x
		sta 	(zTemp0)
		;
		plp
		bcs 	_PDExit
		phy
		ldy 	#1
		lda 	XSNumber1+1,x
		sta 	(zTemp0),y
		ply
_PDExit:
		rts

		.send code

; ************************************************************************************************
;
;									Changes and Updates
;
; ************************************************************************************************
;
;		Date			Notes
;		==== 			=====
;
; ************************************************************************************************
